# Keil uVision project STM32F4-Discovery-sdio-fatfs.uvproj, settings and files
target stm32f4_sdio_fatfs (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: bin
  c flags: Optim=3 oTime=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,HSE_VALUE=8000000
  c include: ..\;..\CMSIS\Include;..\CMSIS\STM32F4xx\Include;..\STM32F4_Discovery;..\STM32F4xx_StdPeriph_Driver\inc;..\sdio;..\fatfs
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group main
    ../: system_stm32f4xx.c main.c stm32f4xx_conf.h stm32f4xx_it.c uart_to_printf.c
  group MDK-ARM
    ../: startup_stm32f4xx.s
  group STM32F4xx_StdPeriph_Driver
    ../STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_exti.c stm32f4xx_rcc.c misc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_sdio.c stm32f4xx_dma.c
  group Discovery
    ../STM32F4_Discovery/: discoveryf4utils.c
  group SDIO
    ../sdio/: stm32f4_discovery_sdio_sd.c stm32f4_discovery_sdio_sd_LowLevel.c sdio_debug.c
  group fatfs
    ../fatfs/: diskio.c ff.c ff_debug.c
